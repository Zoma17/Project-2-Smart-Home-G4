# Keil uVision project prj4_uart.uvproj, settings and files
target prj4_uart (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: prj4_uart
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c PLL.c UART.c startup_TM4C123.s LCD.c DIO.c Delay.c Pot_ADC.c Switch.c
  group include
    ./: PLL.h tm4c123gh6pm.h UART.h LCD.h LCD_Config.h DIO.h Delay.h Pot_ADC.h Switch.h ARM_Tiva-C.h STD_Types.h PORT.h
