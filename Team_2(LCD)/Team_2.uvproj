# Keil uVision project Team_2.uvproj, settings and files
target Team_2 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Team_2
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s
  group src
    ../../CSE 312 Microprocessor Based Systems [Spring 2019]/Keil Projects/Project4_UART/: PLL.c
  group include
    ../../CSE 312 Microprocessor Based Systems [Spring 2019]/Keil Projects/Project4_UART/: PLL.h tm4c123gh6pm.h
