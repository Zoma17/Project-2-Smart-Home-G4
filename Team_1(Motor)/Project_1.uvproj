# Keil uVision project Project_1.uvproj, settings and files
target Team_1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project_1
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s
  group src
    ../../CSE 312 Microprocessor Based Systems [Spring 2019]/Keil Projects/Project4_UART/: PLL.c
    ./: Team_1_main.c init_port&portDirection.c UART.c temp_sensor.c
  group include
    ../../CSE 312 Microprocessor Based Systems [Spring 2019]/Keil Projects/Project4_UART/: PLL.h
    ./: ARM_Tiva-C.h PORT.h STD_Types.h UART.h tm4c123gh6pm.h
